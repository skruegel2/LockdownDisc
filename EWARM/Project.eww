<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LockdownDisc.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SBMLockdownDisc\SBMLockdownDisc.ewp</path>
    </project>
    <batchBuild />
</workspace>
